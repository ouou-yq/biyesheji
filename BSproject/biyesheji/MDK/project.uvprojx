# Keil uVision project project.uvprojx, settings and files
target Target_1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\driver;..\firmware\Library\inc;..\firmware\Library\src;..\firmware\Start;..\User;..\Delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group driver
    ../driver/: LRlight.c LRlight.h Key.c Key.h ZDmada.c ZDmada.h Buzzer.c Buzzer.h WeiDeng.c WeiDeng.h OLED.c OLED.h OLED_Font.h Timer2.c Timer2.h BlueTooth.c BlueTooth.h LightSensor.c LightSensor.h RainSensor.c RainSensor.h mpu6050.c mpu6050.h JQ8900.c JQ8900.h Radar.c Radar.h
  group start
    ../firmware/Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../firmware/Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Delay
    ../Delay/: Delay.c Delay.h
